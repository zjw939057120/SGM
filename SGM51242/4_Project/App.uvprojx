# Keil uVision project App.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, __FPU_USED, ARM_MATH_CM4, __CC_ARM, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\0_Library\CMSIS\inc;..\0_Library\STM32F4xx\Core\inc;..\0_Library\STM32F4xx\Standard_Peripheral\inc;..\1_Board_Support_Package\inc;..\2_Hardware_Driver\inc;..\3_User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../3_User/src/: main.c application.c
  group Hardware_Driver
    ../2_Hardware_Driver/src/: SGM51242.c
  group Board_Support_Package
    ../1_Board_Support_Package/src/: delay.c spi.c usart.c
  group STM32_Standard_Peripheral
    ../0_Library/STM32F4xx/Standard_Peripheral/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group STM32_Core
    ../0_Library/STM32F4xx/Core/src/: startup_stm32f4xx.s system_stm32f4xx.c
    ../0_Library/CMSIS/lib/: arm_cortexM4lf_math.lib
